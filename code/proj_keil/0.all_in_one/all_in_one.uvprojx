# Keil uVision project all_in_one.uvprojx, settings and files
target Debug In Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mpu9250_spi_int.out
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_LPC54114J256BD64_cm4
  c misc: --c99
  c include: ..\..\applications\qn9021_uart_ble;..\..\bsp_smartbalance;..\..\csp_lpc54114;..\..\components\ble;..\..\components\ble\fw;..\..\components\ble\qn_app;..\..\components\ble\qn_config;..\..\components\ble\qn_eaci;..\..\components\ble\qn_isp;..\..\components\mpu9250;..\..\components\tb6612fng;..\..\components\kalman_filter;..\..\components\attitude_control;..\..\components\motor_control;..\..\components\rtt_jlink
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: ..\..\applications\LPC54114J256_cm4.scf
  group applications
    ../../csp_lpc54114/: startup_LPC54114_cm4.s
    ../../applications/all_in_one/: main.c
  group csp
    ../../csp_lpc54114/: fsl_adc.c fsl_clock.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_debug_console.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_flashiap.c fsl_flexcomm.c fsl_fmeas.c fsl_gint.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_i2s.c fsl_i2s_dma.c fsl_inputmux.c fsl_mrt.c fsl_pint.c fsl_power.c fsl_reset.c fsl_rtc.c fsl_sctimer.c fsl_spi.c fsl_spi_dma.c fsl_usart.c fsl_usart_dma.c fsl_utick.c fsl_wwdt.c system_LPC54114_cm4.c keil_lib_power.lib
  group bsp
    ../../bsp_smartbalance/: board.c clock_config.c pin_mux.c
  group ble_stack
    ../../components/ble/qn_app/: app_data.c app_env.c app_generic.c app_msg.c app_util.c
    ../../components/ble/qn_config/: qn_config.c
    ../../components/ble/qn_eaci/: eaci.c eaci_uart.c
    ../../components/ble/qn_isp/: qn_isp.c qn_isp_api.c application.h
    ../../components/ble/: ble_handler.c ble_memory.c ble_uart_int.c ble_wakeup.c
  group mpu9250
    ../../components/mpu9250/: driver_spi_mpu9250.c
  group tb6612fng
    ../../components/tb6612fng/: driver_pwm_tb6612fng.c
  group kalman_filter
    ../../components/kalman_filter/: kalman_filter.c
  group attitude_control
    ../../components/attitude_control/: attitude_control.c
  group motor_ctrl
    ../../components/motor_control/: motor_ctrl.c
  group rtt_jlink
    ../../components/rtt_jlink/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
