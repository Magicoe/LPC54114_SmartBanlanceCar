# Keil uVision project qei_dc_m4f.uvprojx, settings and files
target Debug In Flash (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: qei_dualcore_m4f.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_LPC54114J256BD64_cm4, CORE1_IMAGE_COPY_TO_RAM
  c include: ..\..\bsp_smartbalance;..\..\csp_lpc54114;..\..\applications\qei_dualcore;..\..\components\multicore_2.2.0\mcmgr\src;..\..\components\rtt_jlink
  asm define: CPU_LPC54114J256_M4, DEBUG,__CC_ARM,KEIL
  asm include: .\Objects_m0p
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: ..\..\applications\LPC54114J256_cm4.scf
  group applications
    ../../csp_lpc54114/: startup_LPC54114_cm4.s
    ../../applications/qei_dualcore/: main_m4f.c incbin.s
  group csp
    ../../csp_lpc54114/: fsl_adc.c fsl_clock.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_debug_console.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_flashiap.c fsl_flexcomm.c fsl_fmeas.c fsl_gint.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_i2s.c fsl_i2s_dma.c fsl_inputmux.c fsl_mrt.c fsl_pint.c fsl_power.c fsl_reset.c fsl_rtc.c fsl_sctimer.c fsl_spi.c fsl_spi_dma.c fsl_usart.c fsl_usart_dma.c fsl_utick.c fsl_wwdt.c system_LPC54114_cm4.c keil_lib_power.lib
  group bsp
    ../../bsp_smartbalance/: board.c clock_config.c pin_mux.c
  group rtt_jlink
    ../../components/rtt_jlink/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group mcmgr-mcmgr
    ../../components/multicore_2.2.0/mcmgr/src/: mcmgr.c mcmgr_internal_core_api_lpc54114.c
