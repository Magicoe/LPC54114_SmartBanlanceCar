# Keil uVision project qei_dc_m0p.uvprojx, settings and files
target Debug In Flash (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC54114J256BD64:M0plus NXP
  pack: Keil.LPC54000_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: qei_dualcore_m0p.out
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bincombined --bincombined_base=0x20010000 --output=$Lcore1_image.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_LPC54114J256BD64_cm0plus, NDEBUG
  c include: ..\..\applications\qei_sct;..\..\bsp_smartbalance;..\..\csp_lpc54114;..\..\components\rtt_jlink;..\..\components\multicore_2.2.0\mcmgr\src
  asm define: CPU_LPC54114J256_M0, __CC_ARM,KEIL, SLAVEBOOT, NO_CRP, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: ..\..\applications\LPC54114J256_cm0plus.scf
  group applications
    ../../csp_lpc54114/: startup_LPC54114_cm0plus.s
    ../../applications/qei_dualcore/: main_m0p.c
  group csp
    ../../csp_lpc54114/: fsl_adc.c fsl_clock.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_flashiap.c fsl_flexcomm.c fsl_fmeas.c fsl_gint.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_i2s.c fsl_i2s_dma.c fsl_inputmux.c fsl_mrt.c fsl_pint.c fsl_power.c fsl_reset.c fsl_rtc.c fsl_sctimer.c fsl_spi.c fsl_spi_dma.c fsl_usart.c fsl_usart_dma.c fsl_utick.c fsl_wwdt.c keil_lib_power_m0.lib system_LPC54114_cm0plus.c
  group bsp
    ../../bsp_smartbalance/: board.c clock_config.c pin_mux.c
  group mcmgr-mcmgr
    ../../components/multicore_2.2.0/mcmgr/src/: mcmgr.c mcmgr_internal_core_api_lpc54114.c
